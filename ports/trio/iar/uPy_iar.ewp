# IAR project uPy_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 67
  General.FPU2: 0
  ICCARM.CCDefines: _DEBUG; HW_ASSISTED_COHERENCY; NWDOG; INCLUDE_ATF; MDC_MDIO_OPERATION; CONFIG_DAL_RTL8367C; RELEASE_BUILD
  ICCARM.IExtraOptions: --diag_warning=Pe193; --diag_suppress=Pe1835; --diag_error=Pe940; --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\; ..\..\..\extmod; ..\..\..\ports\trio; ..\..\..\ports\trio\portal; ..\..\..\ports\trio\msvc; ..\..\..\ports\trio\build-standard
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: __ASSEMBLER__; HW_ASSISTED_COHERENCY
  OBJCOPY.OOCOutputFile: MotionPLC.srec
  ILINK.IlinkOutputFile: MotionPLC.elf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../py/: argcheck.c asmarm.c asmbase.c asmrv32.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c cstack.c emitbc.c emitcommon.c emitglue.c emitinlinerv32.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitndebug.c emitnrv32.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c moderrno.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c mpprint.c mpstate.c mpz.c nativeglue.c nlr.c nlraarch64.c nlrmips.c nlrpowerpc.c nlrrv32.c nlrrv64.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcode.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objringio.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c pairheap.c parse.c parsenum.c parsenumbase.c persistentcode.c profile.c pystack.c qstr.c reader.c repl.c ringbuf.c runtime.c runtime_utils.c scheduler.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    ../../../ports/trio/: trio_mphal.c
    ../../../ports/trio/portal/: micropython_portal.c
