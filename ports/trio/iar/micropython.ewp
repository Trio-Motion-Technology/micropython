# IAR project micropython.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\rlucas\Trio\MCSim4\dev\micropython; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\portal; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\msvc; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\build-standard
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MCIMX35 NXP MCIMX35
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 69
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: C:\Users\rlucas\Trio\MCSim4\dev\micropython; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\portal; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\msvc; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\build-standard; C:\Users\rlucas\Trio\MCSim4\dev\micropython\ports\trio\module
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../../../py/: argcheck.c asmarm.c asmarm.h asmbase.c asmbase.h asmrv32.c asmrv32.h asmthumb.c asmthumb.h asmx64.c asmx64.h asmx86.c asmx86.h asmxtensa.c asmxtensa.h bc.c bc.h bc0.h binary.c binary.h builtin.h builtinevex.c builtinhelp.c builtinimport.c compile.c compile.h cstack.c cstack.h dynruntime.h emit.h emitbc.c emitcommon.c emitglue.c emitglue.h emitinlinerv32.c emitinlinethumb.c emitinlinextensa.c emitnarm.c emitnative.c emitndebug.c emitnrv32.c emitnthumb.c emitnx64.c emitnx86.c emitnxtensa.c emitnxtensawin.c formatfloat.c formatfloat.h frozenmod.c frozenmod.h gc.c gc.h grammar.h lexer.c lexer.h malloc.c map.c misc.h modarray.c modbuiltins.c modcmath.c modcollections.c moderrno.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c mpconfig.h mperrno.h mphal.h mpprint.c mpprint.h mpstate.c mpstate.h mpthread.h mpz.c mpz.h nativeglue.c nativeglue.h nlr.c nlr.h nlraarch64.c nlrmips.c nlrpowerpc.c nlrrv32.c nlrrv64.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c obj.h objarray.c objarray.h objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcode.c objcode.h objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objexcept.h objfilter.c objfloat.c objfun.c objfun.h objgenerator.c objgenerator.h objgetitemiter.c objint.c objint.h objint_longlong.c objint_mpz.c objlist.c objlist.h objmap.c objmodule.c objmodule.h objnamedtuple.c objnamedtuple.h objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objringio.c objset.c objsingleton.c objslice.c objstr.c objstr.h objstringio.c objstringio.h objstrunicode.c objtuple.c objtuple.h objtype.c objtype.h objzip.c opmethods.c pairheap.c pairheap.h parse.c parse.h parsenum.c parsenum.h parsenumbase.c parsenumbase.h persistentcode.c persistentcode.h profile.c profile.h pystack.c pystack.h qstr.c qstr.h qstrdefs.h reader.c reader.h repl.c repl.h ringbuf.c ringbuf.h runtime.c runtime.h runtime0.h runtime_utils.c scheduler.c scope.c scope.h sequence.c showbc.c smallint.c smallint.h stackctrl.c stackctrl.h stream.c stream.h unicode.c unicode.h vm.c vmentrytable.h vstr.c warning.c
    ../portal/: micropython_portal.c micropython_portal.h
    ../../../extmod/: modtime.c
    ../module/: module.c
    ../: mpconfigport.h mpconfigtypes.h qstrdefsport.h trio_mphal.c trio_mphal.h
    ../msvc/: unistd.h
